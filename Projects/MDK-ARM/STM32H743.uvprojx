# Keil uVision project STM32H743.uvprojx, settings and files
target Template (6070000::V6.7::.\ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=1
  c define: STM32H743xx,USE_HAL_DRIVER,SPINE_NO_FILE_IO
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers;..\..\Middlewares;..\..\User;..\..\Middlewares\SPINE\include;
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c selftest.c tgx_selftest.cpp raster_probe.cpp raster_test.cpp spine_platform.cpp spine_test.cpp
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_qspi.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group Readme
    ../../: readme.txt
  group Drivers/BSP/MPU
    ../../Drivers/BSP/MPU/: mpu.c
  group Drivers/BSP/SDRAM
    ../../Drivers/BSP/SDRAM/: sdram.c
  group Drivers/BSP/LCD
    ../../Drivers/BSP/LCD/: lcd.c ltdc.c tft_spi.c
  group Drivers/BSP/QSPI
    ../../Drivers/BSP/QSPI/: qspi.c
  group Drivers/BSP/NORFLASH
    ../../Drivers/BSP/NORFLASH/: norflash.c
  group Drivers/BSP/SDMMC
    ../../Drivers/BSP/SDMMC/: sdmmc_sdcard.c
  group Drivers/BSP/LED
    ../../Drivers/BSP/LED/: led.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/source/: ff.c ffunicode.c ffsystem.c diskio.c
  group Middlewares/TGX
    ../../Middlewares/TGX/: Color.cpp Fonts.cpp
  group Middlewares/RASTER
    ../../Middlewares/RASTER/: raster2d.cpp
  group Middlewares/SPINE
    ../../Middlewares/SPINE/src/spine/: Animation.cpp AnimationState.cpp AnimationStateData.cpp Atlas.cpp AtlasAttachmentLoader.cpp Attachment.cpp AttachmentLoader.cpp AttachmentTimeline.cpp Bone.cpp BoneData.cpp BoneLocal.cpp BonePose.cpp BoneTimeline.cpp BoundingBoxAttachment.cpp ClippingAttachment.cpp ColorTimeline.cpp Constraint.cpp ConstraintData.cpp ConstraintTimeline.cpp ConstraintTimeline1.cpp CurveTimeline.cpp DeformTimeline.cpp DrawOrder.cpp DrawOrderFolderTimeline.cpp DrawOrderTimeline.cpp Event.cpp EventData.cpp EventTimeline.cpp Extension.cpp IkConstraint.cpp IkConstraintData.cpp IkConstraintPose.cpp IkConstraintTimeline.cpp InheritTimeline.cpp Interpolation.cpp Json.cpp LinkedMesh.cpp MathUtil.cpp MeshAttachment.cpp PathAttachment.cpp PathConstraint.cpp PathConstraintData.cpp PathConstraintMixTimeline.cpp PathConstraintPose.cpp PathConstraintPositionTimeline.cpp PathConstraintSpacingTimeline.cpp PhysicsConstraint.cpp PhysicsConstraintData.cpp PhysicsConstraintPose.cpp PhysicsConstraintTimeline.cpp PointAttachment.cpp RTTI.cpp RegionAttachment.cpp RotateTimeline.cpp ScaleTimeline.cpp Sequence.cpp SequenceTimeline.cpp ShearTimeline.cpp Skeleton.cpp SkeletonBinary.cpp SkeletonBounds.cpp SkeletonClipping.cpp SkeletonData.cpp SkeletonJson.cpp SkeletonRenderer.cpp Skin.cpp Slider.cpp SliderData.cpp SliderMixTimeline.cpp SliderPose.cpp SliderTimeline.cpp Slot.cpp SlotCurveTimeline.cpp SlotData.cpp SlotPose.cpp SlotTimeline.cpp SpineObject.cpp TextureLoader.cpp TextureRegion.cpp Timeline.cpp TransformConstraint.cpp TransformConstraintData.cpp TransformConstraintPose.cpp TransformConstraintTimeline.cpp TranslateTimeline.cpp Triangulator.cpp Update.cpp VertexAttachment.cpp
